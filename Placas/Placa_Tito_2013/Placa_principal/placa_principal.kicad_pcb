# Repository cdrfiuba/tito

File README.md:

Project created on: 2011-04-29 21:04:24
Project last updated on: 2013-04-11 14:27:10
Project members:
 Martín Mello Teggia <martinmt139@gmail.com>
 Damián Cudero <misael.k@gmail.com>
 anonimo anonimo <nin@guno.com>
 Gisela Farace <gisela.farace@gmail.com>
 Gustavo Crescentini <guscres@gmail.com>

TITO el autito más bonito.

[Descargar copia del repositorio](https://labi.fi.uba.ar/codigo/tito/archive/tip.zip)

## KiCad design Placas/Placa_Tito_2013/Placa_principal/placa_principal.kicad_pcb

Schematic: placa_principal.sch, Tito, el autito más bonito

Parts:
C1: 100n
C2, C3: 15 p
C4: 100 n
D1, D2, D3, D4: LED
IC1: ATMEGA88A-A; TQFP32
JP1, JP2, JP3: PUENTE FALLBACK
P1, P3: ADICIONAL 5V
P2, P4: ADICIONAL GND
P5: Puerto Serie
P6: Programador
P11, P12: ADICIONAL 3,3V
Q1: BC548; TO92
R1, R2, R3, R4: 220
R5, R6: 10 k
R7: 10 K
SW1: BOTÓN 1
SW2: BOTÓN 2
SW3: BOTÓN RESET
X1: 18,432 M

Connections:
+5V: IC1.4, IC1.6, IC1.18, P1.1, P3.1, P5.4, P6.2, R5.1, R6.1, R7.1; also elsewhere on the board
/BOTÓN 1: IC1.32, R5.2, SW1.1
/BOTÓN 2: IC1.14, R6.2, SW2.1
/Control Motores/Motor A Entrada 1: IC1.10; also elsewhere on the board
/Control Motores/Motor A Entrada 2: IC1.9; also elsewhere on the board
/Control Motores/Motor B Entrada 1: JP1.2; also elsewhere on the board
/Control Motores/Motor B Entrada 2: IC1.1; also elsewhere on the board
/LED1: IC1.12, R1.1
/LED2: IC1.2, R2.1
/LED3: JP2.2, R3.1
/LED4: JP3.2, R4.1
/MISO: IC1.16, JP2.1, P6.1
/MOSI: IC1.15, JP1.1, P6.4
/PIN HABILITADOR: IC1.11, Q1.2
/RESET: C4.1, IC1.29, P6.5, R7.2, SW3.1
/RX: IC1.30, P5.2
/SCK: IC1.17, JP3.1, P6.3
/Sensores/Habilitador sensores: Q1.3; also elsewhere on the board
/Sensores/Sensor 1: IC1.19; also elsewhere on the board
/Sensores/Sensor 2: IC1.22; also elsewhere on the board
/Sensores/Sensor 3: IC1.23; also elsewhere on the board
/Sensores/Sensor 4: IC1.24; also elsewhere on the board
/Sensores/Sensor 5: IC1.25; also elsewhere on the board
/Sensores/Sensor 6: IC1.26; also elsewhere on the board
/Sensores/Sensor 7: IC1.27; also elsewhere on the board
/Sensores/Sensor 8: IC1.28; also elsewhere on the board
/TX: IC1.31, P5.3
/Xtal1: C2.1, IC1.7, X1.1
/Xtal2: C3.1, IC1.8, X1.2
GND: C1.2, C2.2, C3.2, C4.2, IC1.3, IC1.5, IC1.21, P2.1, P4.1, P5.1, P6.6, SW1.2, SW2.2, SW3.2; also elsewhere on the board
unnamed: C1.1, IC1.20
unnamed: D3.2 (K), R3.2
unnamed: D4.2 (K), R4.2
unnamed: D1.2 (K), R1.2
unnamed: D2.2 (K), R2.2

Notes on the sheet:
Programador
Leds de control
Sensores
Motores
Alimentación

Parts:
C5, C7: 10 n
C6: 2200 u
C8: 2,2 u
C9: 100 u
K1: Servo
P7: Motor 1
P8: Motor 2
R8: 47 k
U1: DRV8833

Connections:
+BATT: C5.1, C6.1, C7.1, R8.1, U1.12; also elsewhere on the board
/Control Motores/MOTOR A SALIDA 1: P7.1, U1.2
/Control Motores/MOTOR A SALIDA 2: P7.2 (PM), U1.4
/Control Motores/MOTOR B SALIDA 1: P8.1, U1.7
/Control Motores/MOTOR B SALIDA 2: P8.2 (PM), U1.5
/Control Motores/Motor A Entrada 1: U1.16; also elsewhere on the board
/Control Motores/Motor A Entrada 2: U1.15; also elsewhere on the board
/Control Motores/Motor B Entrada 1: U1.9; also elsewhere on the board
/Control Motores/Motor B Entrada 2: U1.10; also elsewhere on the board
GND: C6.2, C7.2, C8.2, C9.2, K1.1, U1.3, U1.6, U1.13; also elsewhere on the board
unnamed: R8.2, U1.1
unnamed: C5.2, U1.11
unnamed: C8.1, U1.14
unnamed: C9.1, K1.3

Schematic: Alimentacion.sch

Parts:
C10, C11: 100 n
C12, C13: 220 u
C14, C15: 10 n
P9: Batería 7,2V
P10: Batería 3,6V
SW4: INTERRUPTOR BATERÍA 7,2V
SW5: INTERRUPTOR REGULADOR 3,3V
U10: REG_104-5
U11: REG_104-3.3

Connections:
+5V: C12.1, U10.2 (Vout); also elsewhere on the board
+BATT: P10.2 (PM); also elsewhere on the board
GND: C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, P9.1, U10.3 (GND), U11.3 (GND); also elsewhere on the board
unnamed: C11.1, SW5.1, SW5.2, U11.1 (Vin)
unnamed: C10.1, P10.1, SW4.1, SW4.2, U10.1 (Vin), U10.5 (ENABLE), U11.5 (ENABLE)
unnamed: C14.1, U10.4 (NR)
unnamed: C15.1, U11.4 (NR)
VDD: P9.2 (PM), SW4.3, SW5.3

Schematic: Sensores.sch

Parts:
R9, R10, R11, R12, R13, R14, R15, R16: 180
R17, R18, R19, R20, R21, R22, R23, R24: 100
RV1, RV2, RV3, RV4, RV5, RV6, RV7, RV8: POT 20 k
U2, U3, U4, U5, U6, U7, U8, U9: TCRT1000

Connections:
+5V: U2.4, U3.4, U4.4, U5.4, U6.4, U7.4, U8.4, U9.4; also elsewhere on the board
/Sensores/Habilitador sensores: R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2; also elsewhere on the board
/Sensores/Sensor 1: RV1.2, RV1.3, U2.3; also elsewhere on the board
/Sensores/Sensor 2: RV2.2, RV2.3, U3.3; also elsewhere on the board
/Sensores/Sensor 3: RV3.2, RV3.3, U4.3; also elsewhere on the board
/Sensores/Sensor 4: RV4.2, RV4.3, U5.3; also elsewhere on the board
/Sensores/Sensor 5: RV5.2, RV5.3, U6.3; also elsewhere on the board
/Sensores/Sensor 6: RV6.2, RV6.3, U7.3; also elsewhere on the board
/Sensores/Sensor 7: RV7.2, RV7.3, U8.3; also elsewhere on the board
/Sensores/Sensor 8: RV8.2, RV8.3, U9.3; also elsewhere on the board
GND: R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, U2.2, U3.2, U4.2, U5.2, U6.2, U7.2, U8.2, U9.2; also elsewhere on the board
unnamed: R14.1, U7.1
unnamed: R13.1, U6.1
unnamed: R15.1, U8.1
unnamed: R11.1, U4.1
unnamed: R22.1, RV6.1
unnamed: R17.1, RV1.1
unnamed: R18.1, RV2.1
unnamed: R19.1, RV3.1
unnamed: R10.1, U3.1
unnamed: R9.1, U2.1
unnamed: R21.1, RV5.1
unnamed: R24.1, RV8.1
unnamed: R23.1, RV7.1
unnamed: R16.1, U9.1
unnamed: R12.1, U5.1
unnamed: R20.1, RV4.1

Notes on the sheet:
Resistencias de seguridad

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
Board: 2 copper layers, 65.0 x 107.5 mm, 91 parts (42 on the bottom side), 65 nets.

Other parts of the board:
1PIN2mm, 1PIN2mm#2, 1PIN2mm#3, 1PIN2mm#4, 1PIN2mm#5, 1PIN2mm#6, 1PIN2mm#7: P***; 1PIN2mm

## KiCad design tito/Placa_Tito_2013/Placa_principal/placa_principal.kicad_pcb

Parts:
C1: 100 nF
C2: 1000 uF
C3: 100n
C4: 220 uF
C5: 10 nF
C6, C8: 100nF
C7: 100uF
D1, D2, D3, D4, D5, D6, D7, D8: DIODE
D9, D10, D11, D12: LED
IC1: ATMEGA88-P; DIL28
JP1, JP2, JP3: JUMPER
K1: Servo
K2: Jumper con doble posicion
P1: Puerto Serie
P2: Motor 1
P3: Motor 2
P4: Bateria 3,6V
P5: Bateria 7,2V
P6: Programador
P7, P8, P9: CONN_1
P10, P11, P12, P13, P14, P15: CONN_1
R1, R2, R10, R11, R12, R13: R sensor
R3, R19: PULL UP
R4, R5, R6, R7, R8, R9: 100
R14: 10 K
R15, R16, R17, R18: R led
RV1, RV2, RV3, RV4, RV5, RV6: POT
SERVO_U1, SERVO_U2: CNY70
SW1: SWITCH COMUN
SW2: SW_PUSH_SMALL
SW3: BOTON DE INTERRUPCION
U3, U4, U6, U7: CNY70
U5: L298D
U8: REG_104-5

Connections:
+5V: C1.1, C4.1, C6.2, IC1.7 (VCC), IC1.20 (AVCC), P1.4, P6.2, P12.1, P14.1, R1.2, R2.2, R3.1, R10.2, R11.2, R12.2, R13.2, R14.1, R19.1, SERVO_U1.C (COL), SERVO_U2.C (COL), U3.C (COL), U4.C (COL), U5.9 (Vss), U6.C (COL), U7.C (COL), U8.2 (Vout)
+8V: C7.1, K1.3, K2.3, P5.2 (PM)
+BATT: C2.1, D5.2 (K), D6.2 (K), D7.2 (K), D8.2 (K), P4.2 (PM), U5.4 (Vs)
/ENABLEA: IC1.9 ((PCINT6/XTAL1/TOSC1)PB6), U5.6 (EN_A)
/ENABLEB: IC1.10 ((PCINT7/XTAL2/TOSC2)PB7), U5.11 (EN_B)
/IN_1A: IC1.12 ((PCINT22/OC0A/AIN0)PD6), U5.5 (IN_1)
/IN_2A: IC1.11 ((PCINT21/OC0B/T1)PD5), U5.7 (IN_2)
/IN_3B: IC1.15 ((PCINT1/OC1A)PB1), U5.10 (IN_3)
/IN_4B: IC1.16 ((PCINT2/OC1B/~SS~)PB2), U5.12 (IN_4)
/LED1: IC1.14 ((PCINT0/CLKO/ICP1)PB0), R15.1
/LED2: IC1.6 ((PCINT20/XCK/T0)PD4), R17.1
/LED3: IC1.13 ((PCINT23/AIN1)PD7), R18.1
/LED4: IC1.18 ((PCINT4/MISO)PB4), JP2.2, P6.1
/MOSI: IC1.17 ((PCINT3/OC2/MOSI)PB3), JP1.1, P6.4
/MOT_1A: D1.2 (K), D5.1 (A), P2.2 (PM), U5.2 (OUT_1)
/MOT_2A: D2.2 (K), D6.1 (A), P2.1, U5.3 (OUT_2)
/MOT_3B: D3.2 (K), D7.1 (A), P3.2 (PM), U5.13 (OUT_3)
/MOT_4B: D4.2 (K), D8.1 (A), P3.1, U5.14 (OUT_4)
/RESET: C3.1, IC1.1 ((PCINT14/~RESET~)PC6), P6.5, R14.2, SW2.1
/RX: IC1.2 ((PCINT16/RXD)PD0), P1.2
/SCK: IC1.19 ((PCINT5/SCK)PB5), JP3.1, P6.3
/SENSOR 1: IC1.26 ((PCINT11/ADC3)PC3), RV1.2, RV1.3, U3.E (EMI)
/SENSOR 2: IC1.25 ((PCINT10/ADC2)PC2), RV2.2, RV2.3, U6.E (EMI)
/SENSOR 3: IC1.24 ((PCINT9/ADC1)PC1), RV3.2, RV3.3, U4.E (EMI)
/SENSOR 4: IC1.23 ((PCINT8/ADC0)PC0), RV4.2, RV4.3, U7.E (EMI)
/SENSOR 5: IC1.27 ((PCINT12/SDA/ADC4)PC4), P10.1, RV5.2, RV5.3, SERVO_U1.E (EMI)
/SENSOR 6: IC1.28 ((PCINT14/SCL/ADC5)PC5), P11.1, RV6.2, RV6.3, SERVO_U2.E (EMI)
/SERVO: JP1.2, K1.2 (PM)
/TX: IC1.3 ((PCINT17/TXD)PD1), P1.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.2, C8.2, D1.1 (A), D2.1 (A), D3.1 (A), D4.1 (A), D9.2 (K), D10.2 (K), D11.2 (K), D12.2 (K), IC1.8 (GND), IC1.22 (GND), K1.1, P1.1, P5.1, P6.6, P13.1, P15.1, R4.2, R5.2, R6.2, R7.2, SERVO_U1.K (C), SERVO_U2.K (C), SW1.2, SW2.2, SW3.2, U3.K (C), U4.K (C), U5.1 (Current_Sensing_A), U5.8 (GND), U5.15 (Current_Sensing_B), U6.K (C), U7.K (C), U8.3 (GND)
unnamed: R2.1, SERVO_U2.A
unnamed: R1.1, SERVO_U1.A
unnamed: R11.1, U4.A
unnamed: R10.1, U3.A
unnamed: C8.1, IC1.21 (AREF)
unnamed: D12.1 (A), R18.2
unnamed: D11.1 (A), R17.2
unnamed: D10.1 (A), R16.2
unnamed: D9.1 (A), R15.2
unnamed: IC1.5 ((PCINT19/OC2B/INT1)PD3), P8.1
unnamed: IC1.4 ((PCINT18/INT0)PD2), P7.1
unnamed: P9.1, R19.2, SW3.1
unnamed: JP2.1, R16.1
unnamed: R9.1, RV6.1
unnamed: R8.1, RV5.1
unnamed: R7.1, RV4.1
unnamed: R5.1, RV2.1
unnamed: C5.1, U8.4 (NR)
unnamed: JP3.2, R3.2, SW1.1
unnamed: R4.1, RV1.1
unnamed: R6.1, RV3.1
unnamed: R13.1, U7.A
unnamed: R12.1, U6.A
unnamed: K2.1, K2.2 (PM), P4.1, U8.1 (Vin), U8.5 (ENABLE)

Notes on the sheet:
Programador
Resistencias de seguridad
10.8 V
Leds de control
Regulador de tension
Interrupciones libres
Botones
Motores

Board: 2 copper layers, 65.0 x 100.0 mm, 83 parts (2 on the bottom side), 54 nets.

Other parts of the board:
1PIN: P***; 1pin
1PIN2mm, 1PIN2mm#2, 1PIN2mm#3, 1PIN2mm#4, 1PIN2mm#5: P***; 1PIN2mm

## Commit log

2011-04-30 primer commit realizado, se procede a subir al repo el proyecto con la placa. db = BaseDeDatos.BaseDeDatos() u = db.get_user(user)
2011-04-30 Cambios minimos en la placa, se empezo con la generacion de la netlist.
2011-05-07 Cambiamos de regulador a un LDO de más corriente. Cambiamos algunos pines para facilitar el diseño del PCB.
2011-05-07 Agrego los archivos del L298 a pedido de martin.
2011-05-14 Cambios a la placa, routeada pero con muchos cables y faltan algunas vias. Agregado magia de diodos para Puente-H.
2011-05-28 nuevo trabajo sobre el pcb, agregamos las especificaciones del regulador de tension, falta cambiar el encapsulado del mismo, agregar smd.
2011-06-04 agrego regulador de tension, y TERMINAMOS EL PCB!!!
2011-06-08 Corregido problema de conectividad en la placa entre las tierras, y agregado un plano de masa (bajo el regulador de tension)
2011-06-15 reestructure el pcb, y agregue el boton. ahora esta linda la placa
2011-06-16 borre algunas pistas que estaban duplicadas, agrego el tito.h con algunas definiciones para ir construyendo en base a eso.
2011-07-23 Correcciones a tito.h, agregado tito.c y terminada la placa (comprobado todo).
2011-07-30 Makefile agregado, arrancamos con el codigo de prueba.
2011-08-20 empezamos de nuevo el codigo
2011-08-27 Corregimos codigo para empezar a habilitar el pwm, hay un corto en el puente H, hay que solucionarlo antes de seguir
2011-09-03 Solucionado el corto, probamos que los leds y el sensor 1 anden (lo hacen), y escribimos el codigo basico de control del auto para probar la semana que viene
2011-09-10 subi .lib y .mod cny70 + algo te placa sensores
2011-11-01 Agrego la placa para un solo sensor
2011-11-02 Placa para un sensor terminada, ANDA!. Ya anda la parte electronica completa, y se esta empezando con el codigo basico.
2011-11-09 Agregados define para sensores. Ahora se puede usar directamente SENSOR_IZQUIERDA, SENSOR_MEDIO y SENSOR_DERECHA.
2011-11-09 Agregado test.c con máquina de estados, y un diagrama de la fsm en un png.
2011-11-11 Cambios y pruebas para que la fsm ande en un micro AVR
2011-11-11 Makefile: agregado un "program" sin sudo, para el WinAVR.
2011-11-11 Máquina de estados funcionando en atmega8.
    Se sacaron los punteros a función (reemplazado por un int,
    manejado por una función), y se puso el array de transiciones en
    el Program Space.
    Para contar la cantidad de transiciones se recorre el array
    antes de empezar el ciclo principal.
    El for que recorre las transiciones en el ciclo principal ahora
2011-11-12 Optimizaciones varias a un codigo estable con muchas transiciones.
2011-11-12 codigo para 4 sensores, todavia falta
2011-11-26 estamos de vuelta en bs as y no se que tienen los ultimos cambios
2011-12-16 codigo un rato antes de la carrera (anda!!)
2011-12-16 vamos a competir con esto:
2012-02-11 creamos los saltos en la tabla, anda!!
2012-02-25 Separamos la placa de tito en 2, una carpeta que contiene lo hecho hasta ahora, y otra placa que tiene lo que va a ser el nuevo pcb de tito, todavia por hacer. Tambien agregamos los .lib y .mod que v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
2012-08-18 Agregado un C de prueba de punteros a función.
2012-08-27 Creamos la nueva tabla, sobreescribimos el viejo tito.c
2012-08-28 Terminada la tabla de estados para cuatro sensores
2012-08-28 ajustando valores de los volviendo y volvio
2012-08-28 Sacado degrade de inicializacion; cambios de velocidades para probar.
2012-08-31 Listo para competir! Puestas velocidades para motores a 8.5V
2012-08-31 Retoques de velocidad
2012-10-06 Contemplando nuevo motor 50:1 HP. Emparejados motores y reducidos COEFICIENTEs
2012-10-13 Emparejadas velocidades de motores para ruedas de menor diametro
2012-10-20 Agregadas pruebas PID
2012-10-22 Agregamos un codigo para facilitar los cambios de estado. Este codigo funciona bien.
2012-10-22 Nuevos valores
2012-10-22 Anda a 22.7 segs las 5 vueltas (espastico, y le falta mejorar para uno de los lados).
2012-10-22 Cambio total de codigo, intento usar las interrupciones para invertir el estado de los pines, no anda todavia, hace cualquier cosa.
2012-10-23 Ahora andan los estados con el pwm y el pwm negado, pero no es posible hacer andar el codigo anterior con este método, hay un bug en algun lugar!
2012-10-26 Codigo de debugueo agregado
2012-10-26 23,5 segs para ambos lados, listo para competir
2012-10-27 Agregado codigo prueba pid 2
2012-10-27 Maxima potencia en Lasalle, usado para competir
2012-10-27 2 milesimas mas rapido que el codigo anterior
2012-11-03 Codigo estable para competidores lentos
2012-11-08 Agrego codigo seguro
2012-11-08 Codigo uno de competencia
2012-11-08 Cambios extremistas que cuelgan a Tito
2012-11-10 No encontramos el punto justo, queda aca para seguir avanzando.
2012-11-10 Un paso mas cerca del estable
2012-11-10 Un paso mas cerca del estable 2
2012-11-10 nuevo estable
2012-11-10 Realmente estable
2012-11-10 Para competir 1: lento pero seguro
2012-11-10 Para competir 2: menos lento, mas seguro
2012-11-10 Tomando riesgos 1
2012-11-10 Tomando riesgos 2, puede competir
2012-11-10 Tomando riesgos 3, algo mas estable
2012-11-10 abs 1
2012-11-10 abs 2: el arriesgau
2012-11-17 Arrancamos la placa nueva
2012-11-23 Estable ahora tiene "para competir 2", y normal tiene "abs 1"
2012-11-23 Estable tiene "para competir 2"
2012-11-24 Agregado macro de "USAR_FRENOS". Es errático. Pronto habrá tracción delantera (gracias a la mecánica de Gisela)
2012-12-15 Terminamos el diseño del esquematico de la nueva placa, falta asociar componentes
2012-12-22 Algunos cambios en la alimentacion del servo, y asociacion de los primeros componentes
2013-02-23 Agregamos placa 2013, con el esquematico completo
2013-03-09 Liberadas interrupciones del micro para usar con futuros encoders, emprolijado esquematico
2013-03-16 Empezado el ruteo
2013-03-23 Mas ruteo, incompleto
2013-04-13 Se terminaron de acomodar los componentes en la placa, y se inició el routeo de la misma
2013-04-13 falto agregar 1 componente que se creó de la placa
2013-04-20 Casi finalizamos de routear la placa
2013-04-27 Terminado el ruteo! Incluidos los Gerber, drill, y Daiquiris de Frutilla
2013-05-04 Agrego una seccion para el codigo del nuevo autito, y mapeo todos los pines.
2013-05-04 Agrego los archivos que faltaban
2013-05-04 Acomodo los archivos en el repo de tito
2013-05-04 Acomodo mas el repo
2013-05-04 Acomodo mas el repo 2
2013-05-04 Acomodo mas el repo 3
2013-05-04 Borro los .bin y .hex
2013-05-18 Agrego el datasheet del CNY70
2013-05-24 Agrego un archivo con la placa como se ve en el pcb
2013-05-25 Subido un mejor preview de la imagen del PCB, agregado un SVG con mismos fines.
2013-05-26 Les saqué los fill a los SVG para que estén más claros.
2013-06-01 Cambios para compilar a ATMega88.
2013-06-01 Mejoras a placa principal
2013-06-07 Probando código sin uso de PROGMEM
2013-06-07 Nuevo pantallazo del esquemático
2013-06-07 Cambio algunas definiciones, y agrego el primer codigo probado en el auto que prende leds con el boton
2013-06-08 Commit para seguir en otro lado
2013-06-08 Primeros ajustes para adaptar la lib_pwm al ATMega88
2013-06-08 Agrego codigo de control de los motores
2013-06-08 Actualizados SVG y Pantallazo.
2013-06-08 Borrados archivos innecesarios e ignorados. Corregidas rutas lib en Kicad.
2013-06-08 Actualizado manejo de velocidades según nuevo código. Ajuste makefile.
2013-06-08 Cambios pre-carrera, no anda un sensor por lo que no se puedo competir
2013-07-12 Agrego las bibliotecas del tcrt1000, y cambio los componentes en el esquemático
2013-07-13 Se termino de routear la placa con los nuevos sensores
2013-08-24 Agrego el datasheet del regulador de tensión
2013-09-14 Reconfigurados PWM, no se usa lib_pwm
2013-09-21 Corregido modo PWM, gracias a Burman
2013-10-03 Configurados PWM para ambos motores.
2013-10-03 Ahora la FSM se inicializa afuera de int main(). Optimizaciones varias según consejo de guía Atmel AVR4027.
2013-10-03 Agrego funcion para apagar los motores y prenderlos
2013-10-03 Agregamos el AD para los sensores
2013-10-05 Maquina de estados con switch. Velocidades para Estable.
2013-10-12 Cambios al ADC para hacer PID en vez de Máquina de Estados
2013-10-19 Anda el ADC, oh happy day
2013-10-21 Agrego los archivos que faltaban en el último commit
2013-10-22 Gracias a Burman, hay puerto serie.
2013-10-24 PD funcional.
2013-10-24 Agrego el i, que no anda, y el codigo para 6 sensores
2013-10-26 Híbrido PID con máquina de estados.
2013-10-29 Ajustes PID.
2013-10-31 6 sensores. Funcion debug sensores. Ajustes PID.
2013-11-02 Nuevos cambios sobre el pid, resulta en un estado mas o menos estable, pero no tan rapido
2013-11-05 PI estable a bajas velocidades. Python para debuggear serie.
2013-11-05 PID estable a velocidades medias, nuevo codigo apra control de velocidades de los motores no probado
2013-11-07 Ajustes Serial, Ajustes PID
2013-11-09 Estable con afuera
2013-11-09 'Estable
2013-11-26 Cambios de bahia no comiteados
2013-11-30 Volvió el código estable, con los agregados del servo.
2014-02-15 Agrego hoja de datos del BC548C, y realizo cambios propuestos sobre el esquematico de la placa
2014-02-28 Agregado cristal externo
2014-03-07 Empezados conversores 5V a 3,3V y viceversa en esquemático.
2014-05-12 Creo y agrego el esquematico de nuestro nuevo puente H (DRV8833), falta corregir ruta de la biblioteca
2014-05-17 Empezados cambios en esquemático para puente H SMD, DRV8833. Agregado datasheet del mismo al repo.
2014-05-30 Agregado módulo para DRV8833 (HTSSOP16)
2014-06-05 Separadas partes del esquématico en varias hojas. Ajustes al esquemático.
2014-06-12 Ajustes de estandarización de nombres en componentes y etiquetas del esquemático. Removido cny70 del .pro, agregado datasheet tcrt1000
2014-06-14 Terminado esquemático. Comenzado a asociar componentes.
2014-07-04 Asociado componente que faltaba, reseteados componentes de la placa.
2014-07-05 Reempezado el pcb.
2014-07-07 Preparado para hacer un tcrt1000 de patas dobladas
2014-07-19 Colocados 8 sensores en la placa.
2014-08-02 Empezados a colocar componentes en la placa
2014-08-02 Empezado modulo nuevo para Interruptor
2014-08-16 Seguimos posicionando componentes en el PBC
2014-08-20 Terminamos de posicionar componentes, y comenzamos el routeo
2014-08-23 Ruteada placa.
2014-08-26 Retoques a la placa, archivos de fabricación
2014-09-03 Archivos de fabricación
2014-09-04 Prueba de coeficientes 1
2014-09-06 vuelvo a valores estables
2014-09-06 Precompetencia
2016-08-05 Agrego archivo readme.
